Commit message: update package

File: hoverboard/urdf/hoverboard.urdf (robot description, URDF)
Before this commit: robot squarbo, 6 links, 5 joints
Joints:
- joint camera_joint: origin xyz=0.05 0 0.04 rpy=0 0 3.14 -> xyz=0.05 0 0.04 rpy=0 0 0
